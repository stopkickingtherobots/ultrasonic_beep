<?xml version="1.0" encoding="utf-8"?>
<workspace>
	<project>
		<path>$WS_DIR$/mbed_4_2.ewp</path>
	</project>
	<batchBuild></batchBuild>
</workspace>